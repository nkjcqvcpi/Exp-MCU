		ORG 0000H
		LJMP MAIN
		ORG 000BH
		LJMP IT0P
		ORG 0100H
MAIN:
		MOV SP,#60H
		MOV TMOD,#02H
		CLR A
		MOV R7,A
		MOV R6,A
		MOV R5,A
		MOV R4,400
		MOV TL0,#06H
		MOV TH0,#06H
		SETB EA
		SETB ET0
		SETB TR0
HERE:
		AJMP HERE
IT0P:
		PUSH PSW
		PUSH Acc
		CJNZ R4,BACK
		MOV R4,4000
		MOV A,#01H
		ADD A,
BACK:
		POP Acc
		POP PSW
		RETI
		END